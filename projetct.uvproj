# Keil uVision project projetct.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: projetct +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c dht11.c oled.c DS1302.c key.c display.c
